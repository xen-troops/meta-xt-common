IMAGE_INSTALL_append = " \
    domu-network \
    glmark2 \
    kmscube \
"
