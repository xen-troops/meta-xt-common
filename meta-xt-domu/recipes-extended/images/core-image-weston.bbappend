IMAGE_INSTALL_append = " \
    expect \
    ltrace \
    strace \
    evtest \
"
