FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
    file://0001-arm-renesas-Enable-RPC-HF-MTD-support-for-all-ULCB-b.patch \
"
