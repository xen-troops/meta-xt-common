require inc/xen-install.inc

