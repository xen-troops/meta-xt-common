IMAGE_INSTALL_append = " \
    expect \
    ltrace \
    evtest \
"
