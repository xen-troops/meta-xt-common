# Append domain name
hostname .= "-domf"
