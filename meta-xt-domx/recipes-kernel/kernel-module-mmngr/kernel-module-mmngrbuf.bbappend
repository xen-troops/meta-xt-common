PSEUDO_IGNORE_PATHS .= ",${KERNELSRC}/include"
