IMAGE_INSTALL_append = " xen-tools"
IMAGE_INSTALL_append = " ${XT_GUEST_INSTALL}"
