
DEPENDS:remove = " qemu-native qemu-helper-native"

