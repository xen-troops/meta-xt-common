IMAGE_INSTALL:append = " \
    weston-notification \
"
